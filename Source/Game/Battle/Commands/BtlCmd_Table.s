;********************************
; BTLCMD_TABLE.S
;********************************
;	Author:	Patrick Meehan/Dylan "I'mJustSoMadFlavaClever" Mayo
;	(c)2000	Interactive Imagination
;	All rights reserved
;********************************
;RETURNS VALUE IN D
?BTL_GET_CMD_BYTE
	
	FGET16		H,L,BTL_TABLE_COPY_FROM
	LD			D,(HL)
	
	RET
	

;********************************
?BTL_CMD_COPY_CMD

	FGET16		B,C,BTL_TABLE_COPY_FROM
	FGET16		H,L,BTL_TABLE_COPY_TO
	
	LD		D,BTL_CMD_SIZE
	
_LOOP
	LD_HLI_BCI
	DEC		D
	JR		NZ,_LOOP
	
	RET

;********************************
; BTL_CMD_BASE_PTR		--	command base ptr  
; BTL_TEXT_BUFFER_PTR	--	ptr to buffer to copy to
;ALSO COPIES A SPACE, THEN THE COST OF THE COMMAND
?BTL_CMD_COPY_NAME
	FGET16		B,C,BTL_CMD_BASE_PTR
	LD			A,B
	OR			C
	JR			Z,_BLANK	
	LD			HL,BTL_CMD_NAME_OFFSET
	ADD			HL,BC
	LD			B,H
	LD			C,L
	FGET16		H,L,BTL_TEXT_BUFFER_PTR
	
	LD			D,BTL_CMD_NAME_SIZE	
_LOOP
	LD_HLI_BCI
	DEC		D
	JR		NZ,_LOOP
	
	LD		A,(BTL_COPY_COST_FLAG)
	AND		A
	RET		Z
	
	LD		A,?SPCE
	LD		(HLI),A
	
	GET16	B,C,BTL_CMD_BASE_PTR
	INC		BC
	INC		BC
	
	LD		A,(BC)
	LD		(HL),A
	
	RET
	
_BLANK
	FGET16	H,L,BTL_TEXT_BUFFER_PTR
	LD		A,?SPCE
	LD		D,BTL_CMD_NAME_SIZE

_BLANK_LOOP
	LD		(HLI),A
	DEC		D
	JR		NZ,_BLANK_LOOP
	
	LD		A,(BTL_COPY_COST_FLAG)
	AND		A
	RET		Z
	
	XOR		A
	LD		(HLI),A
	LD		(HLI),A
	LD		(HLI),A
	LD		(HLI),A
	
	RET	

;********************************
;FORMAT:
;TEMPLATE 1
;PRFX_NAME_FUNC_PTR			DW		PTR TO MY FUNCTION
;PRFX_NAME_COST				DB		HOW MUCH ENERGY DO I USE
;PRFX_NAME_TARGET			DB		WHATS MY TARGET MODE
;PRFX_NAME_MENU				DB		WHAT MENU DO I USE?
;TEMPLATE 2
;PRFX_NAME_RATING			DB		WHATS MY RATING
;PRFX_NAME_CMDELEM			DB		ANY ELEMENTALY STUFF?
;AND THEN 2 BYTES OF THE FOLLOWING (SUMMON || ITEM || (REPEAT && CHANCE))
;SPELLS USE ITEM, ITEMS ARE BASICLY ALTERNATE COST SPELLS
;PRFX_NAME_SUMMON			DW		PTR TO WHAT IT SUMMONS
;PRFX_NAME_ITEM						PTR TO ITEM TO USE	
;PRFX_NAME_DAMAGE					 Max damage of cmd
;PRFX_NAME_CHANCE					CHANCE OF SUCCESS, % 0F FF
;TEMPLATE 3
;PRFX_NAME_NAME[0-6]		DL		7 bytes OF THE NAME CHARS OF THE COMMAND
;BTL_CMD_TEMPLATE	MACRO	name,func,cost,target,menu,rating,cmdelem,repeat,chance,name[0-6]

CMD_TEMPLATE_TABLE

ATK_STANDARD 	BTL_CMD_TEMPLATE1	ATK_STANDARD,?CMD_FUNC_MELEE,$00,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2 	ATK_STANDARD,BTL_CMD_RATING_ATK0,$00,80,BTL_NORM_HIT_CHANCE
				BTL_CMD_TEMPLATE3	ATK_STANDARD,?FU,?IL,?GL,?HL,?TL,?SPCE,?HTRI
				
CMD_SUMMON		BTL_CMD_TEMPLATE1	CMD_SUMMON,?CMD_FUNC_SUMMON,$00,BTL_TARGET_ALLYEMPTY,BTL_CMD_MENU_RING
				BTL_CMD_TEMPLATE2 	CMD_SUMMON,BTL_CMD_RATING_ATK4,$00,$00,$00
				BTL_CMD_TEMPLATE3	CMD_SUMMON,?SU,?UL,?ML,?ML,?OL,?NL,?SPCE
				
CMD_SUMMON_MAGI	BTL_CMD_TEMPLATE1	CMD_SUMMON_MAGI,?CMD_FUNC_SUMMON_MAGI,$00,BTL_TARGET_ALLYEMPTY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	CMD_SUMMON_MAGI,BTL_CMD_RATING_ATK4,$00,$00,$00
				BTL_CMD_TEMPLATE3	CMD_SUMMON_MAGI,?SU,?UL,?ML,?ML,?OL,?NL,?XU
				
CMD_ITEM 		BTL_CMD_TEMPLATE1 	CMD_ITEM,?CMD_FUNC_ITEM,$00,BTL_TARGET_DEPENDANT,BTL_CMD_MENU_ITEM
				BTL_CMD_TEMPLATE2	CMD_ITEM,BTL_CMD_RATING_HEAL0,$00,$00,$00
				BTL_CMD_TEMPLATE3	CMD_ITEM,?IU,?TL,?EL,?ML,?SPCE,?SPCE,?SPCE
				
CMD_RUN			BTL_CMD_TEMPLATE1	CMD_RUN,?CMD_FUNC_RUN,0,BTL_TARGET_NONE,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	CMD_RUN,BTL_CMD_RATING_ATK0,$00,$01,$FC
				BTL_CMD_TEMPLATE3	CMD_RUN,?RU,?UL,?NL,?SPCE,?SPCE,?SPCE,?SPCE
				
CMD_SPELL		BTL_CMD_TEMPLATE1 	CMD_SPELL,?CMD_FUNC_SPELL,$00,BTL_TARGET_DEPENDANT,BTL_CMD_MENU_SPELL
				BTL_CMD_TEMPLATE2 	CMD_SPELL,BTL_CMD_RATING_ATK0,$00,$00,$00
				BTL_CMD_TEMPLATE3 	CMD_SPELL,?SU,?PL,?EL,?LL,?LL,?SPCE,?SPCE
				
CMD_FOCUS		BTL_CMD_TEMPLATE1	CMD_FOCUS,?CMD_FUNC_FOCUS,$00,BTL_TARGET_ME,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	CMD_FOCUS,BTL_CMD_RATING_HEAL4,$00,$00,$00
				BTL_CMD_TEMPLATE3	CMD_FOCUS,?FU,?OL,?CL,?UL,?SL,?SPCE,?SPCE

;/*********************************************/
;//	Creature Attacks
;/*********************************************/

ATK_BARRAGE		BTL_CMD_TEMPLATE1	ATK_BARRAGE,?CMD_FUNC_BARRAGE,12,BTL_TARGET_ALLENEMY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_BARRAGE,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_PHYS,STANDARD,106,230
				BTL_CMD_TEMPLATE3	ATK_BARRAGE,?BU,?AL,?RL,?RL,?AL,?GL,?EL


ATK_BEAM		BTL_CMD_TEMPLATE1	ATK_BEAM,?CMD_FUNC_BEAM,12,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_BEAM,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,EARTH,230,243
				BTL_CMD_TEMPLATE3	ATK_BEAM,?BU,?EL,?AL,?ML,?SPCE,?SPCE,?SPCE


ATK_BITE		BTL_CMD_TEMPLATE1	ATK_BITE,?CMD_FUNC_BITE,4,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_BITE,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_PHYS,STANDARD,118,243
				BTL_CMD_TEMPLATE3	ATK_BITE,?BU,?IL,?TL,?EL,?SPCE,?SPCE,?SPCE


ATK_BLAST		BTL_CMD_TEMPLATE1	ATK_BLAST,?CMD_FUNC_BLAST,10,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_BLAST,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_PHYS,WIND,200,243
				BTL_CMD_TEMPLATE3	ATK_BLAST,?BU,?LL,?AL,?SL,?TL,?SPCE,?SPCE


ATK_BLAZE		BTL_CMD_TEMPLATE1	ATK_BLAZE,?CMD_FUNC_BLAZE,8,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_BLAZE,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,FIRE,160,243
				BTL_CMD_TEMPLATE3	ATK_BLAZE,?BU,?LL,?AL,?ZL,?EL,?SPCE,?SPCE


ATK_BOOST		BTL_CMD_TEMPLATE1	ATK_BOOST,?CMD_FUNC_BOOST,15,BTL_TARGET_ALLALLY_ME,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_BOOST,BTL_CMD_RATING_HEAL0+BTL_CMD_RATING_SKILL,LIGHTNING,0,230
				BTL_CMD_TEMPLATE3	ATK_BOOST,?BU,?OL,?OL,?SL,?TL,?SPCE,?SPCE


ATK_BRAMBLE		BTL_CMD_TEMPLATE1	ATK_BRAMBLE,?CMD_FUNC_BRAMBLE,16,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_BRAMBLE,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,LIFE,180,243
				BTL_CMD_TEMPLATE3	ATK_BRAMBLE,?BU,?RL,?AL,?ML,?BL,?LL,?EL


ATK_BURROW		BTL_CMD_TEMPLATE1	ATK_BURROW,?CMD_FUNC_BURROW,5,BTL_TARGET_ME,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_BURROW,BTL_CMD_RATING_HEAL0+BTL_CMD_RATING_SKILL,EARTH,0,255
				BTL_CMD_TEMPLATE3	ATK_BURROW,?BU,?UL,?RL,?RL,?OL,?WL,?SPCE


ATK_CARNAGE		BTL_CMD_TEMPLATE1	ATK_CARNAGE,?CMD_FUNC_CARNAGE,12,BTL_TARGET_ALLENEMY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_CARNAGE,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_PHYS,STANDARD,106,230
				BTL_CMD_TEMPLATE3	ATK_CARNAGE,?CU,?AL,?RL,?NL,?AL,?GL,?EL


ATK_CHARGE		BTL_CMD_TEMPLATE1	ATK_CHARGE,?CMD_FUNC_CHARGE,8,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_CHARGE,BTL_CMD_RATING_HEAL0+BTL_CMD_RATING_SKILL,LIGHTNING,0,243
				BTL_CMD_TEMPLATE3	ATK_CHARGE,?CU,?HL,?AL,?RL,?GL,?EL,?SPCE


ATK_CHOKE		BTL_CMD_TEMPLATE1	ATK_CHOKE,?CMD_FUNC_CHOKE,10,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_CHOKE,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_PHYS,STANDARD,125,243
				BTL_CMD_TEMPLATE3	ATK_CHOKE,?CU,?HL,?OL,?KL,?EL,?SPCE,?SPCE


ATK_CLAW		BTL_CMD_TEMPLATE1	ATK_CLAW,?CMD_FUNC_CLAW,8,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_CLAW,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_PHYS,STANDARD,160,243
				BTL_CMD_TEMPLATE3	ATK_CLAW,?CU,?LL,?AL,?WL,?SPCE,?SPCE,?SPCE


ATK_COIL		BTL_CMD_TEMPLATE1	ATK_COIL,?CMD_FUNC_COIL,3,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_COIL,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,SHADOW,0,243
				BTL_CMD_TEMPLATE3	ATK_COIL,?CU,?OL,?IL,?LL,?SPCE,?SPCE,?SPCE


ATK_CONSUME		BTL_CMD_TEMPLATE1	ATK_CONSUME,?CMD_FUNC_CONSUME,14,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_CONSUME,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_PHYS,STANDARD,140,243
				BTL_CMD_TEMPLATE3	ATK_CONSUME,?CU,?OL,?NL,?SL,?UL,?ML,?EL


ATK_CRACK		BTL_CMD_TEMPLATE1	ATK_CRACK,?CMD_FUNC_CRACK,10,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_CRACK,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,EARTH,200,243
				BTL_CMD_TEMPLATE3	ATK_CRACK,?CU,?RL,?AL,?CL,?KL,?SPCE,?SPCE


ATK_CREMATE		BTL_CMD_TEMPLATE1	ATK_CREMATE,?CMD_FUNC_CREMATE,16,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_CREMATE,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,FIRE,180,243
				BTL_CMD_TEMPLATE3	ATK_CREMATE,?CU,?RL,?EL,?ML,?AL,?TL,?EL


ATK_CRUMBLE		BTL_CMD_TEMPLATE1	ATK_CRUMBLE,?CMD_FUNC_CRUMBLE,8,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_CRUMBLE,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,EARTH,160,243
				BTL_CMD_TEMPLATE3	ATK_CRUMBLE,?CU,?RL,?UL,?ML,?BL,?LL,?EL


ATK_CRUSH		BTL_CMD_TEMPLATE1	ATK_CRUSH,?CMD_FUNC_CRUSH,16,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_CRUSH,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_PHYS,STANDARD,180,243
				BTL_CMD_TEMPLATE3	ATK_CRUSH,?CU,?RL,?UL,?SL,?HL,?SPCE,?SPCE


ATK_CURSE		BTL_CMD_TEMPLATE1	ATK_CURSE,?CMD_FUNC_CURSE,10,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_CURSE,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,SHADOW,200,243
				BTL_CMD_TEMPLATE3	ATK_CURSE,?CU,?UL,?RL,?SL,?EL,?SPCE,?SPCE


ATK_CUTE		BTL_CMD_TEMPLATE1	ATK_CUTE,?CMD_FUNC_CUTE,5,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_CUTE,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,LIFE,0,243
				BTL_CMD_TEMPLATE3	ATK_CUTE,?CU,?UL,?TL,?EL,?SPCE,?SPCE,?SPCE


ATK_CYCLONE		BTL_CMD_TEMPLATE1	ATK_CYCLONE,?CMD_FUNC_CYCLONE,12,BTL_TARGET_ALLENEMY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_CYCLONE,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_PHYS,WIND,106,230
				BTL_CMD_TEMPLATE3	ATK_CYCLONE,?CU,?YL,?CL,?LL,?OL,?NL,?EL


ATK_DEVOUR		BTL_CMD_TEMPLATE1	ATK_DEVOUR,?CMD_FUNC_DEVOUR,16,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_DEVOUR,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_PHYS,STANDARD,180,243
				BTL_CMD_TEMPLATE3	ATK_DEVOUR,?DU,?EL,?VL,?OL,?UL,?RL,?SPCE


ATK_DREAM		BTL_CMD_TEMPLATE1	ATK_DREAM,?CMD_FUNC_DREAM,0,BTL_TARGET_ME,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_DREAM,BTL_CMD_RATING_HEAL0+BTL_CMD_RATING_SKILL,WIND,0,255
				BTL_CMD_TEMPLATE3	ATK_DREAM,?DU,?RL,?EL,?AL,?ML,?SPCE,?SPCE


ATK_DROWN		BTL_CMD_TEMPLATE1	ATK_DROWN,?CMD_FUNC_DROWN,16,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_DROWN,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,WATER,180,243
				BTL_CMD_TEMPLATE3	ATK_DROWN,?DU,?RL,?OL,?WL,?NL,?SPCE,?SPCE


ATK_FANG		BTL_CMD_TEMPLATE1	ATK_FANG,?CMD_FUNC_FANG,8,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_FANG,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_PHYS,STANDARD,160,243
				BTL_CMD_TEMPLATE3	ATK_FANG,?FU,?AL,?NL,?GL,?SPCE,?SPCE,?SPCE


ATK_FLAME		BTL_CMD_TEMPLATE1	ATK_FLAME,?CMD_FUNC_FLAME,4,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_FLAME,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,FIRE,118,243
				BTL_CMD_TEMPLATE3	ATK_FLAME,?FU,?LL,?AL,?ML,?EL,?SPCE,?SPCE


ATK_FLASH		BTL_CMD_TEMPLATE1	ATK_FLASH,?CMD_FUNC_FLASH,12,BTL_TARGET_ALLENEMY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_FLASH,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,LIGHTNING,0,230
				BTL_CMD_TEMPLATE3	ATK_FLASH,?FU,?LL,?AL,?SL,?HL,?SPCE,?SPCE


ATK_FLOCK		BTL_CMD_TEMPLATE1	ATK_FLOCK,?CMD_FUNC_FLOCK,18,BTL_TARGET_ALLENEMY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_FLOCK,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,WIND,175,230
				BTL_CMD_TEMPLATE3	ATK_FLOCK,?FU,?LL,?OL,?CL,?KL,?SPCE,?SPCE


ATK_FORTUNE		BTL_CMD_TEMPLATE1	ATK_FORTUNE,?CMD_FUNC_FORTUNE,2,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_FORTUNE,BTL_CMD_RATING_HEAL0+BTL_CMD_RATING_SKILL,LIFE,0,243
				BTL_CMD_TEMPLATE3	ATK_FORTUNE,?FU,?OL,?RL,?TL,?UL,?NL,?EL


ATK_FRENZY		BTL_CMD_TEMPLATE1	ATK_FRENZY,?CMD_FUNC_FRENZY,12,BTL_TARGET_ALLENEMY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_FRENZY,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_PHYS,STANDARD,106,230
				BTL_CMD_TEMPLATE3	ATK_FRENZY,?FU,?RL,?EL,?NL,?ZL,?YL,?SPCE


ATK_GALE		BTL_CMD_TEMPLATE1	ATK_GALE,?CMD_FUNC_GALE,8,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_GALE,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_PHYS,WIND,160,243
				BTL_CMD_TEMPLATE3	ATK_GALE,?GU,?AL,?LL,?EL,?SPCE,?SPCE,?SPCE


ATK_GOO			BTL_CMD_TEMPLATE1	ATK_GOO,?CMD_FUNC_GOO,3,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_GOO,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,EARTH,0,243
				BTL_CMD_TEMPLATE3	ATK_GOO,?GU,?OL,?OL,?SPCE,?SPCE,?SPCE,?SPCE


ATK_GRAVITY		BTL_CMD_TEMPLATE1	ATK_GRAVITY,?CMD_FUNC_GRAVITY,12,BTL_TARGET_ALLENEMY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_GRAVITY,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,SHADOW,106,230
				BTL_CMD_TEMPLATE3	ATK_GRAVITY,?GU,?RL,?AL,?VL,?IL,?TL,?YL


ATK_GUST		BTL_CMD_TEMPLATE1	ATK_GUST,?CMD_FUNC_GUST,4,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_GUST,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_PHYS,WIND,118,243
				BTL_CMD_TEMPLATE3	ATK_GUST,?GU,?UL,?SL,?TL,?SPCE,?SPCE,?SPCE


ATK_HAUNT		BTL_CMD_TEMPLATE1	ATK_HAUNT,?CMD_FUNC_HAUNT,8,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_HAUNT,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,SHADOW,160,243
				BTL_CMD_TEMPLATE3	ATK_HAUNT,?HU,?AL,?UL,?NL,?TL,?SPCE,?SPCE


ATK_HEAL		BTL_CMD_TEMPLATE1	ATK_HEAL,?CMD_FUNC_HEAL,5,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_HEAL,BTL_CMD_RATING_HEAL0+BTL_CMD_RATING_SKILL,LIFE,0,243
				BTL_CMD_TEMPLATE3	ATK_HEAL,?HU,?EL,?AL,?LL,?SPCE,?SPCE,?SPCE


ATK_IGNITE		BTL_CMD_TEMPLATE1	ATK_IGNITE,?CMD_FUNC_IGNITE,10,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_IGNITE,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,FIRE,125,243
				BTL_CMD_TEMPLATE3	ATK_IGNITE,?IU,?GL,?NL,?IL,?TL,?EL,?SPCE


ATK_IMPALE		BTL_CMD_TEMPLATE1	ATK_IMPALE,?CMD_FUNC_IMPALE,12,BTL_TARGET_ANY_EVASION,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_IMPALE,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_PHYS,STANDARD,200,243
				BTL_CMD_TEMPLATE3	ATK_IMPALE,?IU,?ML,?PL,?AL,?LL,?EL,?SPCE


ATK_INFECT		BTL_CMD_TEMPLATE1	ATK_INFECT,?CMD_FUNC_INFECT,8,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_INFECT,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,SHADOW,140,243
				BTL_CMD_TEMPLATE3	ATK_INFECT,?IU,?NL,?FL,?EL,?CL,?TL,?SPCE


ATK_INFERNO		BTL_CMD_TEMPLATE1	ATK_INFERNO,?CMD_FUNC_INFERNO,12,BTL_TARGET_ALLENEMY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_INFERNO,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,FIRE,106,230
				BTL_CMD_TEMPLATE3	ATK_INFERNO,?IU,?NL,?FL,?EL,?RL,?NL,?OL


ATK_INK			BTL_CMD_TEMPLATE1	ATK_INK,?CMD_FUNC_INK,5,BTL_TARGET_ME,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_INK,BTL_CMD_RATING_HEAL0+BTL_CMD_RATING_SKILL,WATER,0,255
				BTL_CMD_TEMPLATE3	ATK_INK,?IU,?NL,?KL,?SPCE,?SPCE,?SPCE,?SPCE


ATK_JIGGLE		BTL_CMD_TEMPLATE1	ATK_JIGGLE,?CMD_FUNC_JIGGLE,8,BTL_TARGET_ALLENEMY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_JIGGLE,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,EARTH,90,230
				BTL_CMD_TEMPLATE3	ATK_JIGGLE,?JU,?IL,?GL,?GL,?LL,?EL,?SPCE


ATK_JOLT		BTL_CMD_TEMPLATE1	ATK_JOLT,?CMD_FUNC_JOLT,10,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_JOLT,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,LIGHTNING,200,243
				BTL_CMD_TEMPLATE3	ATK_JOLT,?JU,?OL,?LL,?TL,?SPCE,?SPCE,?SPCE


ATK_LAMP		BTL_CMD_TEMPLATE1	ATK_LAMP,?CMD_FUNC_LAMP,3,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_LAMP,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,EARTH,0,243
				BTL_CMD_TEMPLATE3	ATK_LAMP,?LU,?AL,?ML,?PL,?SPCE,?SPCE,?SPCE


ATK_LEAF		BTL_CMD_TEMPLATE1	ATK_LEAF,?CMD_FUNC_LEAF,4,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_LEAF,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,LIFE,118,243
				BTL_CMD_TEMPLATE3	ATK_LEAF,?LU,?EL,?AL,?FL,?SPCE,?SPCE,?SPCE


ATK_MAGMA		BTL_CMD_TEMPLATE1	ATK_MAGMA,?CMD_FUNC_MAGMA,10,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_MAGMA,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,FIRE,200,243
				BTL_CMD_TEMPLATE3	ATK_MAGMA,?MU,?AL,?GL,?ML,?AL,?SPCE,?SPCE


ATK_MAUL		BTL_CMD_TEMPLATE1	ATK_MAUL,?CMD_FUNC_MAUL,10,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_MAUL,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_PHYS,STANDARD,200,243
				BTL_CMD_TEMPLATE3	ATK_MAUL,?MU,?AL,?UL,?LL,?SPCE,?SPCE,?SPCE

				
ATK_MELODY		BTL_CMD_TEMPLATE1	ATK_MELODY,?CMD_FUNC_MELODY,12,BTL_TARGET_ALLENEMY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_MELODY,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,SHADOW,0,230
				BTL_CMD_TEMPLATE3	ATK_MELODY,?MU,?EL,?LL,?OL,?DL,?YL,?SPCE


ATK_MEND		BTL_CMD_TEMPLATE1	ATK_MEND,?CMD_FUNC_MEND,5,BTL_TARGET_ALLALLY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_MEND,BTL_CMD_RATING_HEAL0+BTL_CMD_RATING_SKILL,LIFE,0,230
				BTL_CMD_TEMPLATE3	ATK_MEND,?MU,?EL,?NL,?DL,?SPCE,?SPCE,?SPCE


ATK_MIST		BTL_CMD_TEMPLATE1	ATK_MIST,?CMD_FUNC_MIST,8,BTL_TARGET_ALLALLY_ME,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_MIST,BTL_CMD_RATING_HEAL0+BTL_CMD_RATING_SKILL,WATER,0,230
				BTL_CMD_TEMPLATE3	ATK_MIST,?MU,?IL,?SL,?TL,?SPCE,?SPCE,?SPCE


ATK_MUNCH		BTL_CMD_TEMPLATE1	ATK_MUNCH,?CMD_FUNC_MUNCH,10,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_MUNCH,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_PHYS,STANDARD,200,243
				BTL_CMD_TEMPLATE3	ATK_MUNCH,?MU,?UL,?NL,?CL,?HL,?SPCE,?SPCE


ATK_PACK		BTL_CMD_TEMPLATE1	ATK_PACK,?CMD_FUNC_PACK,18,BTL_TARGET_ALLENEMY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_PACK,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_PHYS,STANDARD,175,230
				BTL_CMD_TEMPLATE3	ATK_PACK,?PU,?AL,?CL,?KL,?SPCE,?SPCE,?SPCE


ATK_PETRIFY		BTL_CMD_TEMPLATE1	ATK_PETRIFY,?CMD_FUNC_PETRIFY,16,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_PETRIFY,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,EARTH,180,243
				BTL_CMD_TEMPLATE3	ATK_PETRIFY,?PU,?EL,?TL,?RL,?IL,?FL,?YL


ATK_PINCH		BTL_CMD_TEMPLATE1	ATK_PINCH,?CMD_FUNC_PINCH,3,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_PINCH,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_PHYS,STANDARD,150,127
				BTL_CMD_TEMPLATE3	ATK_PINCH,?PU,?IL,?NL,?CL,?HL,?SPCE,?SPCE


ATK_POLLEN		BTL_CMD_TEMPLATE1	ATK_POLLEN,?CMD_FUNC_POLLEN,5,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_POLLEN,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,LIFE,0,243
				BTL_CMD_TEMPLATE3	ATK_POLLEN,?PU,?OL,?LL,?LL,?EL,?NL,?SPCE


ATK_PRISM		BTL_CMD_TEMPLATE1	ATK_PRISM,?CMD_FUNC_PRISM,5,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_PRISM,BTL_CMD_RATING_HEAL0+BTL_CMD_RATING_SKILL,WIND,0,243
				BTL_CMD_TEMPLATE3	ATK_PRISM,?PU,?RL,?IL,?SL,?ML,?SPCE,?SPCE


ATK_PUMMEL		BTL_CMD_TEMPLATE1	ATK_PUMMEL,?CMD_FUNC_PUMMEL,8,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_PUMMEL,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_PHYS,STANDARD,160,243
				BTL_CMD_TEMPLATE3	ATK_PUMMEL,?PU,?UL,?ML,?ML,?EL,?LL,?SPCE


ATK_PUNCH		BTL_CMD_TEMPLATE1	ATK_PUNCH,?CMD_FUNC_PUNCH,4,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_PUNCH,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_PHYS,STANDARD,118,243
				BTL_CMD_TEMPLATE3	ATK_PUNCH,?PU,?UL,?NL,?CL,?HL,?SPCE,?SPCE


ATK_QUAKE		BTL_CMD_TEMPLATE1	ATK_QUAKE,?CMD_FUNC_QUAKE,12,BTL_TARGET_ALL_ME,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_QUAKE,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,EARTH,200,230
				BTL_CMD_TEMPLATE3	ATK_QUAKE,?QU,?UL,?AL,?KL,?EL,?SPCE,?SPCE


ATK_ROAR		BTL_CMD_TEMPLATE1	ATK_ROAR,?CMD_FUNC_ROAR,3,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_ROAR,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,WIND,0,243
				BTL_CMD_TEMPLATE3	ATK_ROAR,?RU,?OL,?AL,?RL,?SPCE,?SPCE,?SPCE


ATK_ROOTS		BTL_CMD_TEMPLATE1	ATK_ROOTS,?CMD_FUNC_ROOTS,8,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_ROOTS,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,LIFE,160,243
				BTL_CMD_TEMPLATE3	ATK_ROOTS,?RU,?OL,?OL,?TL,?SL,?SPCE,?SPCE


ATK_SCRATCH		BTL_CMD_TEMPLATE1	ATK_SCRATCH,?CMD_FUNC_SCRATCH,4,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_SCRATCH,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_PHYS,STANDARD,118,243
				BTL_CMD_TEMPLATE3	ATK_SCRATCH,?SU,?CL,?RL,?AL,?TL,?CL,?HL


ATK_SEVER		BTL_CMD_TEMPLATE1	ATK_SEVER,?CMD_FUNC_SEVER,20,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_SEVER,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_PHYS,STANDARD,180,243
				BTL_CMD_TEMPLATE3	ATK_SEVER,?SU,?EL,?VL,?EL,?RL,?SPCE,?SPCE


ATK_SHADE		BTL_CMD_TEMPLATE1	ATK_SHADE,?CMD_FUNC_SHADE,4,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_SHADE,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,SHADOW,118,243
				BTL_CMD_TEMPLATE3	ATK_SHADE,?SU,?HL,?AL,?DL,?EL,?SPCE,?SPCE


ATK_SHAKE		BTL_CMD_TEMPLATE1	ATK_SHAKE,?CMD_FUNC_SHAKE,4,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_SHAKE,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,EARTH,118,243
				BTL_CMD_TEMPLATE3	ATK_SHAKE,?SU,?HL,?AL,?KL,?EL,?SPCE,?SPCE


ATK_SHIELD		BTL_CMD_TEMPLATE1	ATK_SHIELD,?CMD_FUNC_SHIELD,8,BTL_TARGET_ME,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_SHIELD,BTL_CMD_RATING_HEAL0+BTL_CMD_RATING_SKILL,EARTH,0,255
				BTL_CMD_TEMPLATE3	ATK_SHIELD,?SU,?HL,?IL,?EL,?LL,?DL,?SPCE


ATK_SHOCK		BTL_CMD_TEMPLATE1	ATK_SHOCK,?CMD_FUNC_SHOCK,8,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_SHOCK,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,LIGHTNING,160,243
				BTL_CMD_TEMPLATE3	ATK_SHOCK,?SU,?HL,?OL,?CL,?KL,?SPCE,?SPCE


ATK_SHRED		BTL_CMD_TEMPLATE1	ATK_SHRED,?CMD_FUNC_SHRED,16,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_SHRED,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_PHYS,STANDARD,180,243
				BTL_CMD_TEMPLATE3	ATK_SHRED,?SU,?HL,?RL,?EL,?DL,?SPCE,?SPCE


ATK_SLIDE		BTL_CMD_TEMPLATE1	ATK_SLIDE,?CMD_FUNC_SLIDE,3,BTL_TARGET_ME,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_SLIDE,BTL_CMD_RATING_HEAL0+BTL_CMD_RATING_SKILL,EARTH,0,255
				BTL_CMD_TEMPLATE3	ATK_SLIDE,?SU,?LL,?IL,?DL,?EL,?SPCE,?SPCE


ATK_SOAR		BTL_CMD_TEMPLATE1	ATK_SOAR,?CMD_FUNC_SOAR,4,BTL_TARGET_ME,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_SOAR,BTL_CMD_RATING_HEAL0+BTL_CMD_RATING_PHYS,WIND,0,243
				BTL_CMD_TEMPLATE3	ATK_SOAR,?SU,?OL,?AL,?RL,?SPCE,?SPCE,?SPCE


ATK_SONIC		BTL_CMD_TEMPLATE1	ATK_SONIC,?CMD_FUNC_SONIC,10,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_SONIC,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,WIND,125,243
				BTL_CMD_TEMPLATE3	ATK_SONIC,?SU,?OL,?NL,?IL,?CL,?SPCE,?SPCE


ATK_SPARK		BTL_CMD_TEMPLATE1	ATK_SPARK,?CMD_FUNC_SPARK,4,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_SPARK,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,LIGHTNING,118,243
				BTL_CMD_TEMPLATE3	ATK_SPARK,?SU,?PL,?AL,?RL,?KL,?SPCE,?SPCE


ATK_SPONGE		BTL_CMD_TEMPLATE1	ATK_SPONGE,?CMD_FUNC_SPONGE,4,BTL_TARGET_ME,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_SPONGE,BTL_CMD_RATING_HEAL0+BTL_CMD_RATING_SKILL,WATER,0,255
				BTL_CMD_TEMPLATE3	ATK_SPONGE,?SU,?PL,?OL,?NL,?GL,?EL,?SPCE


ATK_SPORE		BTL_CMD_TEMPLATE1	ATK_SPORE,?CMD_FUNC_SPORE,12,BTL_TARGET_ALLENEMY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_SPORE,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,EARTH,118,230
				BTL_CMD_TEMPLATE3	ATK_SPORE,?SU,?PL,?OL,?RL,?EL,?SPCE,?SPCE


ATK_SQUIRT		BTL_CMD_TEMPLATE1	ATK_SQUIRT,?CMD_FUNC_SQUIRT,4,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_SQUIRT,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,WATER,118,243
				BTL_CMD_TEMPLATE3	ATK_SQUIRT,?SU,?QL,?UL,?IL,?RL,?TL,?SPCE


ATK_STING		BTL_CMD_TEMPLATE1	ATK_STING,?CMD_FUNC_STING,8,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_STING,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_PHYS,WATER,118,243
				BTL_CMD_TEMPLATE3	ATK_STING,?SU,?TL,?IL,?NL,?GL,?SPCE,?SPCE


ATK_STORM		BTL_CMD_TEMPLATE1	ATK_STORM,?CMD_FUNC_STORM,12,BTL_TARGET_ALLENEMY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_STORM,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,LIGHTNING,106,230
				BTL_CMD_TEMPLATE3	ATK_STORM,?SU,?TL,?OL,?RL,?ML,?SPCE,?SPCE


ATK_SWARM		BTL_CMD_TEMPLATE1	ATK_SWARM,?CMD_FUNC_SWARM,12,BTL_TARGET_ALLENEMY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_SWARM,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,WIND,160,230
				BTL_CMD_TEMPLATE3	ATK_SWARM,?SU,?WL,?AL,?RL,?ML,?SPCE,?SPCE


ATK_SWING		BTL_CMD_TEMPLATE1	ATK_SWING,?CMD_FUNC_SWING,5,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_SWING,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,LIFE,0,243
				BTL_CMD_TEMPLATE3	ATK_SWING,?SU,?WL,?IL,?NL,?GL,?SPCE,?SPCE


ATK_SYPHON		BTL_CMD_TEMPLATE1	ATK_SYPHON,?CMD_FUNC_SYPHON,8,BTL_TARGET_ALLENEMY_MAGI,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_SYPHON,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,LIFE,118,230
				BTL_CMD_TEMPLATE3	ATK_SYPHON,?SU,?YL,?PL,?HL,?OL,?NL,?SPCE


ATK_TACKLE		BTL_CMD_TEMPLATE1	ATK_TACKLE,?CMD_FUNC_TACKLE,10,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_TACKLE,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_PHYS,STANDARD,200,243
				BTL_CMD_TEMPLATE3	ATK_TACKLE,?TU,?AL,?CL,?KL,?LL,?EL,?SPCE


ATK_TANGLE		BTL_CMD_TEMPLATE1	ATK_TANGLE,?CMD_FUNC_TANGLE,12,BTL_TARGET_ALLENEMY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_TANGLE,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,LIFE,106,230
				BTL_CMD_TEMPLATE3	ATK_TANGLE,?TU,?AL,?NL,?GL,?LL,?EL,?SPCE


ATK_TEMPEST		BTL_CMD_TEMPLATE1	ATK_TEMPEST,?CMD_FUNC_TEMPEST,12,BTL_TARGET_ALLENEMY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_TEMPEST,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,WATER,106,230
				BTL_CMD_TEMPLATE3	ATK_TEMPEST,?TU,?EL,?ML,?PL,?EL,?SL,?TL


ATK_TERROR		BTL_CMD_TEMPLATE1	ATK_TERROR,?CMD_FUNC_TERROR,16,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_TERROR,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,SHADOW,180,243
				BTL_CMD_TEMPLATE3	ATK_TERROR,?TU,?EL,?RL,?RL,?OL,?RL,?SPCE


ATK_THORNS		BTL_CMD_TEMPLATE1	ATK_THORNS,?CMD_FUNC_THORNS,10,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_THORNS,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,LIFE,200,243
				BTL_CMD_TEMPLATE3	ATK_THORNS,?TU,?HL,?OL,?RL,?NL,?SL,?SPCE


ATK_THRUST		BTL_CMD_TEMPLATE1	ATK_THRUST,?CMD_FUNC_THRUST,10,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_THRUST,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_PHYS,STANDARD,200,243
				BTL_CMD_TEMPLATE3	ATK_THRUST,?TU,?HL,?RL,?UL,?SL,?TL,?SPCE


ATK_THUNDER		BTL_CMD_TEMPLATE1	ATK_THUNDER,?CMD_FUNC_THUNDER,16,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_THUNDER,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,LIGHTNING,180,243
				BTL_CMD_TEMPLATE3	ATK_THUNDER,?TU,?HL,?UL,?NL,?DL,?EL,?RL


ATK_TIC_TOC		BTL_CMD_TEMPLATE1	ATK_TIC_TOC,?CMD_FUNC_TIC_TOC,5,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_TIC_TOC,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,SHADOW,0,243
				BTL_CMD_TEMPLATE3	ATK_TIC_TOC,?TU,?IL,?CL,?SPCE,?TU,?OL,?CL


ATK_TIDE		BTL_CMD_TEMPLATE1	ATK_TIDE,?CMD_FUNC_TIDE,8,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_TIDE,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,WATER,160,243
				BTL_CMD_TEMPLATE3	ATK_TIDE,?TU,?IL,?DL,?EL,?SPCE,?SPCE,?SPCE


ATK_TIMBER		BTL_CMD_TEMPLATE1	ATK_TIMBER,?CMD_FUNC_TIMBER,16,BTL_TARGET_ALLENEMY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_TIMBER,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,LIFE,240,230
				BTL_CMD_TEMPLATE3	ATK_TIMBER,?TU,?IL,?ML,?BL,?EL,?RL,?SPCE


ATK_TSUNAMI		BTL_CMD_TEMPLATE1	ATK_TSUNAMI,?CMD_FUNC_TSUNAMI,10,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_TSUNAMI,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,WATER,200,243
				BTL_CMD_TEMPLATE3	ATK_TSUNAMI,?TU,?SL,?UL,?NL,?AL,?ML,?IL


ATK_TURTLE		BTL_CMD_TEMPLATE1	ATK_TURTLE,?CMD_FUNC_TURTLE,2,BTL_TARGET_ME,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_TURTLE,BTL_CMD_RATING_HEAL0+BTL_CMD_RATING_SKILL,WATER,0,255
				BTL_CMD_TEMPLATE3	ATK_TURTLE,?TU,?UL,?RL,?TL,?LL,?EL,?SPCE


ATK_VAMPIRE		BTL_CMD_TEMPLATE1	ATK_VAMPIRE,?CMD_FUNC_VAMPIRE,10,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_VAMPIRE,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,SHADOW,140,243
				BTL_CMD_TEMPLATE3	ATK_VAMPIRE,?VU,?AL,?ML,?PL,?IL,?RL,?EL


ATK_VORTEX		BTL_CMD_TEMPLATE1	ATK_VORTEX,?CMD_FUNC_VORTEX,16,BTL_TARGET_ANY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_VORTEX,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_PHYS,WIND,180,243
				BTL_CMD_TEMPLATE3	ATK_VORTEX,?VU,?OL,?RL,?TL,?EL,?XL,?SPCE


ATK_WHIRL		BTL_CMD_TEMPLATE1	ATK_WHIRL,?CMD_FUNC_WHIRL,12,BTL_TARGET_ALLENEMY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_WHIRL,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_SKILL,WATER,75,230
				BTL_CMD_TEMPLATE3	ATK_WHIRL,?WU,?HL,?IL,?RL,?LL,?SPCE,?SPCE


ATK_WRECK		BTL_CMD_TEMPLATE1	ATK_WRECK,?CMD_FUNC_WRECK,16,BTL_TARGET_ALLENEMY,BTL_CMD_MENU_NONE
				BTL_CMD_TEMPLATE2	ATK_WRECK,BTL_CMD_RATING_ATK0+BTL_CMD_RATING_PHYS,EARTH,180,230
				BTL_CMD_TEMPLATE3	ATK_WRECK,?WU,?RL,?EL,?CL,?KL,?SPCE,?SPCE
 
;********************************
	END
;********************************
